# Keil uVision project project.uvprojx, settings and files
target controller (5060960::V5.06 update 7 (build 960)::.\compiler_version5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;..\core;..\device;..\driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c delay.c gpio_init.c pwm_config.c tim_init.c
  group core
    ../core/: core_cm3.c
  group device
    ../device/: stm32f10x_it.c system_stm32f10x.c
  group startup
    ../startup/: startup_stm32f10x_md.s
  group driver
    ../driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c misc.c stm32f10x_usart.c stm32f10x_exti.c
